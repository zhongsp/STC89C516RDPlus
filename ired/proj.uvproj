# Keil uVision project proj.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: proj +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\App
  group App
    ./App/: smg.c
  group User
    ./User/: main.c
  group Public
    ./Public/: public.c
